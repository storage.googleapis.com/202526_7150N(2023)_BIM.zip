Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-06-14T17:13:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 14 17:13:45 2023 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\759ee022-3bab-4bb7-b5d6-2821236c801b\9917014f-e4e5-4f7d-8c87-7a2154518f1e\ifc * Database version: 5507 * Database creation date: Wed Jun 14 17:13:45 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 14 17:13:45 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 14 17:13:45 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 7150N Shower faucet, 160cc, 7150N(2023):7150N Shower faucet, 160cc:314101
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - NominalDepth: 86.6 mm; NominalHeight: 100.184 mm; NominalWidth: 342.373 mm
Type - General - Author: BIMStone; BIMObjectName: 7150N(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150099427; EN Standard: EN1111; ETIM Class Number: EC011329 Shower mixing tap; Noise Class: I (ISO 3822); Sales Package dimensions (LxWxH): 359 x 128 x 75; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7150N; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7150N
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7150N; 3D View: https://static.oras.com/AR/7150N; Catalog Drawing URL: http://static.oras.com/catdrw/7150N; Dimension Drawing URL: http://static.oras.com/dimdrw/7150N; FDV Document URL: http://www.oras.com/datasheet/7150N/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7150N; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7150N; Interactive AR View URL: https://static.oras.com/AR/7150N; Manufacturer: Oras; Market: International;Sweden; Mobile Product Information URL: http://mpi.oras.com/7150N; Model: 7150N Shower faucet, 160cc; Name_en: 7150N Shower faucet, 160cc; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7150N; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/7150N; Product URL: http://static.oras.com/7150N; Technical DataSheet URL: http://www.oras.com/datasheet/7150N/en; Type Name: 7150N Shower faucet, 160cc; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: Standard aerator; Backflow Prevention EN1717: EB; Connection: Direct connection;Internal thread; Connection Size: G3/4; Eco Flow At 300kPa: 0.00423776 m3/s; Excluded Items: Without couplings; Flow Rate At 300kPa: 0.00776923 m3/s; Installation Type: Wall mounted; Installation Width: CC160 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Easy-Grip surface;Eco feature for water flow; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Pressure Loss With Flow 02ls: 250000 Pa; Shower Parts: MagShelf; Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7150N(2023); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 7150N; Name: 7150N Shower faucet, 160cc; ReplacementCost: n/a; Shape: Sculptured; Size: 220 x 240 x 180 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0586267 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00187706 m3
Identity Data - Mark: 8
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7150N(2023): 7150N Shower faucet, 160cc; Family and Type: 7150N(2023): 7150N Shower faucet, 160cc; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7150N(2023): 7150N Shower faucet, 160cc; Type Id: 7150N(2023): 7150N Shower faucet, 160cc; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
